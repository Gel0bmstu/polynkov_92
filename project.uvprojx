# Keil uVision project project.uvprojx, settings and files
target main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\milandr
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c inits.h defines.h L2G2IS.h MPU-60x0.h SPI.h board.h sensor_inits.h CAN.h LSM6DS33.h SysTick.h PID.h sensor_type_defines.h
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:UART 1.5, Drivers:USB 1.5
